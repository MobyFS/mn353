<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mn353.ewp</path>
  </project>
  <batchBuild/>
</workspace>


