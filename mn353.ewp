# IAR project mn353.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE9x Milandr MDR1986VE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_MDR1986VE9x
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: FreeRTOS\src\include; MDR_Library\inc; startup; mn353\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\src\include; mn353\inc
  OBJCOPY.OOCOutputFile: mn353_mdr.hex
  ILINK.IlinkOutputFile: mn353.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group FreeRTOS
    FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
  group MDR_Library
    MDR_Library/src/: MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_sdio.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group mn353
    MN353/src/: console.c image.c lcd.c led.c main.c output.c restart.c
  group mn353/device
    MN353/src/device/: mlink.c otimer.c serial.c spi.c
  group mn353/userlib
    MN353/src/userlib/: gunzip.c ks.c
  group startup
    startup/: cexit.s cmain.s cstartup_M.s data_init.c exit.c low_level_init.c lz77_init.c lz77_init_single.c vector_table_M.s XXexit.s
